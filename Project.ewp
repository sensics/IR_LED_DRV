# IAR project Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: User; Config; Vendor\STM8S_StdPeriph_Template; Vendor\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ir_led_drvt_debug.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003k3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: ; User; Config; Vendor\STM8S_StdPeriph_Driver\inc; Vendor\STM8S_StdPeriph_Template
  OBJCOPY.OOCOutputFile: ir_led_dev.hex
  group StdPeriph_Drivers
    Vendor/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c stm8s_wwdg.c
  group StdPeriph_Template
    Vendor/STM8S_StdPeriph_Template/: stm8s_conf.h stm8s_it.h
  group User
    User/: array_init.c array_init.h Config.h main.c MCUConfig.h uart_protocol.c uart_protocol.h
