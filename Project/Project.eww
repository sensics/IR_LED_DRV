<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>AllConfigs</name>
      <member>
        <project>Project</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>Project</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


